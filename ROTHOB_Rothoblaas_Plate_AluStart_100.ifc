Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: fe595b37-2071-43d7-8f47-0c74231f2249, NumberOfSaves: 14], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Default Site]
File name: ROTHOB_Rothoblaas_Plate_AluStart_100.ifc
Time: 2026-03-30T10:55:48
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 01
LongName: ROTHOBLAAS

# IfcSite, Default
RefLatitude: 46, 17, 24, 511413; RefLongitude: 11, 14, 5, 895767; RefElevation: 0 mm
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuilding, HEADQUARTER
LongName: HEADQUARTER
Pset_BuildingCommon - NumberOfStoreys: 1
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuildingStorey: Level:1/4" Head, 0_Rothoblaas
In: HEADQUARTER
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 1/4" Head; Type: 1/4" Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 1/4" Head
Other(Type) - Category: Levels; Family Name: Level

# IfcMember: Structural Connections : ROTHOB_Rothoblaas_Plate_AluStart_100 : ALUSTART100_100x90x2400mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_Aluminium
Type - General - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_AluStart_100; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/angle-brackets-and-plates-for-buildings/alu-start#ALU%20START; Revision: 1; UniClass2015Code: Pr_20_76_51_07; UniClass2015Title: Aluminium structural sections; UniClass2015Version: Products v1.33; Version: 2
Type - Constraints - Default Elevation: 1219.2 mm
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_Aluminium
Type - Dimensions - Height_H: 90 mm; HoleQuantity_nhØ14: 12; HoleQuantity_nvØ5: 171; Length_L: 2400 mm; Width_B: 100 mm
Type - Identity Data - OmniClass Number: 23.13.23.11.19.13; Type Name: ALUSTART100_100x90x2400mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: n/a; CECode: ETA-20/0835; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Aluminium system for the connection of buildings to the ground; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_AluStart_100; Features: ALU START angle bracket for timber-to-timber, timber-to-concrete, timber-to-steel joints; Finish: n/a; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Aluminium; MinWeight: 7.8 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: ALUSTART100; ModelReference: n/a; Name: Plate; NominalHeight: 90 mm; NominalLength: 2400 mm; NominalWidth: 100 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 100x90x2400 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate
Pset_MemberCommon - Reference: ALUSTART100_100x90x2400mm
Pset_QuantityTakeOff - Reference: ALUSTART100_100x90x2400mm
BaseQuantities - NetVolume: 0.00256754 m3; NetSurfaceArea: 1.88585 m2
Constraints - Elevation from Level: 0 mm; Host: Level : 0_Rothoblaas; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <0' - 1">
Dimensions - Volume: 0.00256754 m3
Other - Family: ROTHOB_Rothoblaas_Plate_AluStart_100; Family and Type: ROTHOB_Rothoblaas_Plate_AluStart_100: ALUSTART100_100x90x2400mm; Type: ALUSTART100_100x90x2400mm; Type Id: 962473
